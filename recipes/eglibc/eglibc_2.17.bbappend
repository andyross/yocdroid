PRINC = "1"
FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://syslog-socket-path.patch"
